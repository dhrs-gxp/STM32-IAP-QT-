# Keil uVision project STM32_IAP.uvprojx, settings and files
target TARGET1 (6210000::V6.21::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_IAP +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\CMSIS;..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Myfiles\usart;..\Myfiles\delay;..\Myfiles\key;..\Myfiles\flash;..\Myfiles\boot
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Myfiles
    ../Myfiles/usart/: usart.c
    ../Myfiles/delay/: delay.c
    ../Myfiles/flash/: flash.c
    ../Myfiles/boot/: boot.c
    ../Myfiles/key/: key.c
  group Library
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_dma.c
  group Core
    ../CMSIS/: startup_stm32f40_41xxx.s
  group Doc
    ../: readme.txt
